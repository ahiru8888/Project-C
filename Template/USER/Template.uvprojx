# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM\adc;..\SYSTEM\tm_stm32f4_i2c;..\SYSTEM\LCD_I2C;..\SYSTEM\dht11;..\SYSTEM\tm_stm32f4_ssd1306;..\SYSTEM\tm_stm32f4_fonts;..\SYSTEM\tm_stm32f4_delay;..\SYSTEM\tm_stm32f4_i2c\attributes;..\SYSTEM\tm_stm32f4_i2c\defines;..\SYSTEM\tm_stm32f4_i2c\tm_stm32f4_gpio;..\SYSTEM\defines;..\SYSTEM\tm_stm32f4_gpio
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CMSIS
    ../CORE/: startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Libraries
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/tm_stm32f4_i2c/tm_stm32f4_gpio/: tm_stm32f4_gpio.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/tm_stm32f4_i2c/: tm_stm32f4_i2c.c
    ../SYSTEM/tm_stm32f4_delay/: tm_stm32f4_delay.c
    ../SYSTEM/tm_stm32f4_fonts/: tm_stm32f4_fonts.c
    ../SYSTEM/tm_stm32f4_ssd1306/: tm_stm32f4_ssd1306.c
    ../SYSTEM/dht11/: dht11.c
